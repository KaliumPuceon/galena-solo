## boards/shields/galena_solo/Kconfig.defconfig
```kconfig
if SHIELD_GALENA_SOLO

config ZMK_KEYBOARD_NAME
    default "galena-solo"

endif # SHIELD_GALENA_SOLO
```
